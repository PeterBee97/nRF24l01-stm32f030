# Keil uVision project STM32F030Demo.uvprojx, settings and files
target Stm32f030demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: TX
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\HARDWARE;..\STM32F03x_FWLib\src;..\User;..\SYSTEM;..\STM32F03x_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group HARDWARE
    ../HARDWARE/: led.c USART1.c PWM.c 24l01.c spi.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_spi.c
